# Keil uVision project flow_calib.uvprojx, settings and files
target src (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flow_calib +hex
  AfterMake: copy_hex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -Wno-unused-parameter -Wno-sign-compare -Wno-unused-but-set-variable
  c include: ..\src\cmsis\CM3\CoreSupport;..\src\cmsis\CM3\DeviceSupport\ST\STM32F10x;..\src\stm32_lib\inc;..\src\user;..\src\user\components;..\src\user\bsp;..\src\user\device;..\src\user\service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../src/cmsis/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../src/cmsis/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group stm_lib
    ../src/stm32_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../src/user/bsp/: bsp_delay.c bsp_iic.c
  group device
    ../src/user/device/: XGZP6818D.c
  group components
    ../src/user/components/: sf_lib.c
  group service
    ../src/user/service/: first_order_filter.c calib.c measure_data.c
  group main
    ../src/user/: main.c stm32f10x_it.c flow_calib.c
software components: RTOS:kernel 3.1.3
